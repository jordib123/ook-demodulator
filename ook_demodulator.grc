<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ook_demod</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>4e3</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>50e3</value></param>
<param><key>low_cutoff_freq</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>20e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>1e-3</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>1e-3</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ook_demod_block</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import time
import numpy as np
from gnuradio import gr

class blk (gr.sync_block):
    """
    Block to decode the data on an already squared signal, comprised of 0's and 1's.
    """

    def __init__ (self
                , symbol_rate = 600
		, sample_rate = 1e6
		, manchester_decoding = False
                , sink_file = None):  # only default arguments here
        """
        Constructor.

        Args:
            symbol_rate -&gt; Rate of symbols

            sample_rate -&gt; Number of samples per second

	    manchester_decoding -&gt; Enable/disable manchester decoding

            sink_file -&gt; File to dump the packets. If it's 'None', prints them on STDOUT
        """
        gr.sync_block.__init__(
            self,
            name = 'OOK demod',
            in_sig = [np.float32],
            out_sig = []
        )

	self.manchester_decoding = manchester_decoding

	self.sink_file = None
	if(sink_file != None):
          self.sink_file = open(sink_file, "a")

	# amount of samples per symbol
	self.threshold = sample_rate / symbol_rate
	# amount of samples that can be wrong when counting the 1's and 0's
	self.error_threshold = self.threshold / 4

	self.packet = ''
        self.count_1 = 0 # Counts consecutive 1's
	self.count_0 = 0 # Counts consecutive 0's
	self.sample_1_complete = False
	self.sample_0_complete = False


    def packet_found(self):
	self.packet += '0' # Last 0 of packet is never detected due to the bounded 0 count (in process_sample_0), so add manually

	if(self.manchester_decoding):
	  self.packet = self.manchester_decoder(self.packet)

	self.output_packet(self.packet)
	self.packet = ''

   
    def output_packet(self, output):
	if(self.sink_file):
	  self.sink_file.write(output + '\n')
	else:
	  print(output)


    def count_samples(self, sample1, sample2):
	if(sample1 == 1):
	  self.count_1 += 1
	  if(sample2 == 0):
	    self.sample_1_complete = True 
	elif(sample1 == 0):
	  self.count_0 += 1
	  if(sample2 == 1):
	    self.sample_0_complete = True 


    def process_sample_0(self):
	if(self.count_0 &gt; self.threshold - self.error_threshold and self.count_0 &lt; self.threshold + self.error_threshold):
	  self.packet += '0'
	elif(self.count_0 &gt; (self.threshold - self.error_threshold) * 2 and self.count_0 &lt; (self.threshold + self.error_threshold) * 2):
	  self.packet += '00'
	self.count_0 = 0
	self.sample_0_complete = False


    def process_sample_1(self):
	if(self.count_1 &gt; self.threshold - self.error_threshold and self.count_1 &lt; self.threshold + self.error_threshold):
	  self.packet += '1'
	elif(self.count_1 &gt; (self.threshold - self.error_threshold) * 2 and self.count_1 &lt; (self.threshold + self.error_threshold) * 2):
	  self.packet += '11'
	self.count_1 = 0
	self.sample_1_complete = False


    def manchester_decoder(self, packet):
	decode = ''

        for i in range(0, len(packet) - 1, 2):
	  bits = packet[i] + packet[i + 1]
	  if(bits == '10'):
	    decode += '0'
	  elif(bits == '01'):
	    decode += '1'
	  else:
	    i -= 1

	return decode



    def work (self, input_items, *args, **kwargs):
        samples = input_items[0]
	
        signal_detected = np.where(samples == 1)[0]

	if(len(signal_detected) &gt; 0):
	  for i in range(0, len(samples) - 1):
	    self.count_samples(samples[i], samples[i + 1])
	    if(self.sample_1_complete):
	      self.process_sample_1()
	    elif(self.sample_0_complete):
	      self.process_sample_0()
	elif(len(samples) &gt; 0 and len(self.packet) &gt; 0):
	   self.packet_found()

        return len(samples)
</value></param>
<param><key>manchester_decoding</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sink_file</key><value>None</value></param>
<param><key>symbol_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>433.92e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>ook_demod_block</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
